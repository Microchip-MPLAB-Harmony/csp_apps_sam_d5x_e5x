# IAR project spi_ping_pong_with_dma_sam_e54_xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_e54_xpro_iar; ..\src\packs\ATSAME54P20A_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sam_e54_xpro_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_e54_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: device_cache.h toolchain_specifics.h definitions.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/sercom/spim
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/spim/: plib_sercom6_spi.h plib_sercom_spi_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/dmac
    ../src/config/sam_e54_xpro_iar/peripheral/dmac/: plib_dmac.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP
    ../src/packs/ATSAME54P20A_DFP/: device.h atsame54p20a_compat.h atsame54p20a.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/component
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/pio
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm4.h mpu_armv7.h
  group Harmony3/Source Files
    ../src/: main.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: initialization.c interrupts.c exceptions.c startup_iar.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/sercom/spim
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/spim/: plib_sercom6_spi.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/dmac
    ../src/config/sam_e54_xpro_iar/peripheral/dmac/: plib_dmac.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/stdio
    ../src/config/sam_e54_xpro_iar/stdio/: iar_monitor.c
  group Harmony3/Linker File
    ../src/config/sam_e54_xpro_iar/: flash.icf
